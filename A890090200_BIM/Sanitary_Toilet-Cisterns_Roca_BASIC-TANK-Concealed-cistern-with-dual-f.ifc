Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilet-Cisterns_Roca_BASIC-TANK-Concealed-cistern-with-dual-f.ifc
Time: 2021-08-17T17:09:23
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: BASIC TANK- Concealed cistern with dual flush (6/3 L)
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): BASIC TANK- Concealed cistern with dual flush (6/3 L); SKU (BO_prodsku): 890090200; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): In-wall tanks; ProductGroup (BO_prodgroup): In-Wall; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 6/1/2012; EditionNumber (BO_edinum): 1; Width (BO_width): 124; Height (BO_height): 726; Depth (BO_depth): 520; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/890090200; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/890090200; ProductUrl (BO_producturl): http://www.export.roca.com/roca-web/catalog-product-detail?codeProduct=890090200; InstallationInstructions (BO_montins): http://www.export.roca.com/RocaResourceServlet/resources/getMainResource?idObject={9ED6DDE6-014D-4871-A6A3-0E378BE1CF25}; TechnicalDescription (BO_techcert): http://www.export.roca.com/roca-services/productSheet/EX/en/890090200/; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Plastic; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Installation Systems; BimObjectCategoryCode (BO_bocat_code): installation-systems; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 30181515; Uniclass14Code (BO_uniclass_1_4_code): L72164; Uniclass14Description (BO_uniclass_1_4_desc): WC cisterns; Uniclass20Code (BO_uniclass_2_0_code): PR-35-93-90; Uniclass20Description (BO_uniclass_2_0_desc): Wc Cisterns; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93_89; Uniclass2015Description (BO_uniclass2015_desc): WC cisterns; NBSReference (BO_nbs_ref): 35-93-90; NBSReferenceDescription (BO_nbs_desc): Wc Cisterns; OmniClassCode (BO_omniclass_code): 23-31 19 19 19; OmniClassDescription (BO_omniclass_name): Water Closet Tanks; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
